<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\s3t2.ewp</path>
  </project>
  <batchBuild />
</workspace>
